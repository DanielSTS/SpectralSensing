<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>629e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfft</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32e3</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>10000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>500e-3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>nfft</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>nfft</value></param>
</block>
<block>
<key>digital_ofdm_mod</key>
<param><key>id</key><value>digital_ofdm_mod_0</value></param>
<param><key>cp_length</key><value>128</value></param>
<param><key>fft_length</key><value>512</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>modulation</key><value>bpsk</value></param>
<param><key>occupied_tones</key><value>300</value></param>
<param><key>pad_for_usrp</key><value>True</value></param>
<param><key>payload_length</key><value>0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value># encoding: utf-8
import numpy as np
from gnuradio import gr
from scipy.special import erfinv
from math import sqrt
import datetime 


class blk(gr.sync_block): 
  
    energia = 0
    controle = 0 	
    
    def __init__(self, num_amostras = 10, variancia_ruido  = 0, snr = -10): 
       
        gr.sync_block.__init__(
            self,
            name='Detector de Energia', 
            in_sig=[np.complex64],
            out_sig=[np.complex64]
        )
        pfa = 0.1
	self.num_amostras = num_amostras
	self.variancia_ruido = variancia_ruido
	self.snr = snr
	self.limiar = variancia_ruido * ( erfinv(1 - 2*pfa ) * 2 * sqrt(num_amostras) + num_amostras )
	
	
	

    def work(self, input_items, output_items):

	detector = open('/home/daniel/Gnuradio_Workspace/sensoriamento_deteccao_energia/dados.txt','a') 
        vetor_amostras = np.abs(input_items[0])
	limite = self.num_amostras
	
	#print(len(input_items[0]))

	if (self.controle &lt; self.num_amostras): 

		if(len(vetor_amostras) &lt; self.num_amostras): #altera o limite caso o vetor_amostra seja menor que o num_amostras necessárias
			
			limite = len(vetor_amostras)
	
		for i in range (limite): 

			self.energia += vetor_amostras[i] * vetor_amostras[i]
			self.controle += 1
			
			if(self.controle == self.num_amostras):#após calcular a energia é feita a decisão 
		
				if (self.energia &lt; self.limiar):
				
					print("canal livre") 
					dados = ['canal livre',self.energia,self.limiar,self.snr,str(datetime.datetime.now())]
					detector.write('%s' %dados)
					detector.write('\n')
					self.controle = 0
					self.energia = 0
					break

				else:
					print("canal ocupado")
					dados = ['canal ocupado',self.energia,self.limiar,self.snr,str(datetime.datetime.now())]
					detector.write('%s' %dados)
					detector.write('\n')
					self.controle = 0
					self.energia = 0
					break
			
	detector.close()
	return len(output_items[0])









</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_amostras</key><value>1000</value></param>
<param><key>snr</key><value>0</value></param>
<param><key>variancia_ruido</key><value>0.05899904857456255</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1</value></param>
<param><key>_source_code</key><value># encoding: utf-8
import numpy as np
from gnuradio import gr
from scipy.special import erfinv
from math import sqrt


class blk(gr.sync_block): 
  
    energia = 0
    controle = 0
    variancia = 0.0	
    aux_somatorio = 0
    somatorio = 0.0

    def __init__(self, num_amostras = 10): 
       
        gr.sync_block.__init__(
            self,
            name='Variancia do Ruido', 
            in_sig=[np.complex64],
            out_sig=[np.complex64]
        )
        
	self.num_amostras = num_amostras
	
	
	
    def work(self, input_items, output_items):

	
        vetor_amostras = np.abs(input_items[0])
	limite = self.num_amostras
	    
    	if (self.controle &lt; self.num_amostras): 

	    if(len(vetor_amostras) &lt; self.num_amostras): #altera o limite caso o vetor_amostra seja menor que o num_amostras necessárias
		    
	    	limite = len(vetor_amostras)
    
	    for i in range (limite): 

	    	self.energia += vetor_amostras[i] * vetor_amostras[i]
		self.controle += 1
			
	     	if(self.controle == self.num_amostras):
			self.variancia = (1.0/self.num_amostras) * self.energia
			self.somatorio += self.variancia               	   
		        self.controle = 0
		        self.energia = 0
                	self.variancia = 0.0
			self.aux_somatorio += 1
			break
		if(self.aux_somatorio == self.num_amostras):
			print(self.somatorio / self.num_amostras)
			self.aux_somatorio = 0
			self.somatorio = 0	

	return len(output_items[0])









</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_amostras</key><value>1000</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>nfft</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(nfft)</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>6e6</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>6e6</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>freq</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>8</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>min_value</key><value>-100</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>title</key><value>Number Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>units</key><value>Units</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>digital_ofdm_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>epy_block_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_mod_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_1</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
